# Keil uVision project Lab7_8_11.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Lab7_8_11
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group src
    ./: gyro.c lab.c USB.c
  group inc
    ../inc/: ADCSWTrigger.c ADCT0ATrigger.c AGM1264F.c AP.c Blynk.c Board.c BSP.c can.c can0.c Clock.c CortexM.c DAC.c DMASoftware.c DMASPI.c DMATimerRead.c DMATimerWrite.c Dump.c EdgeCount.c EdgeInterruptPortF.c eDisk.c esp8266.c esp8266_base.c esp8266_blynk.c esp8266_fifo.c FIFOsimple.c FlashProgram.c FreqMeasure.c Fuzzy.c GPIO.c HD44780.c I2C0.c I2C1.c I2C2.c I2C3.c I2CB1.c InputCapture.c interrupt.c IRDistance.c LaunchPad.c LED.c LLFifo.c LPF.c Matrix.c max549.c MAX5353.c MQTT.c Nokia5110.c odometry.c opt3101.c PLL.c Profile.c PWM.c PWMDual.c PWMrobot.c Sine.c SSD1306.c SSD2119.c ST7735.c ST7735_PortD.c Switch.c SwitchExternal.c SwitchPA5.c SysTick.c SysTickInts.c Texas.c Timer.c Timer0A.c Timer0APWM.c Timer1A.c Timer2A.c Timer3A.c Timer4A.c Timer5A.c tm4c123gh6pm_startup_ccs.c UART.c UART0int.c UART1.c UART1int.c UART2.c UART5.c Unified_Port_Init.c WTimer0A.c ADCSWTrigger.h ADCT0ATrigger.h AGM1264F.h AP.h asmdefs.h Blynk.h Board.h BSP.h can.h can0.h Clock.h CortexM.h cpu.h DAC.h debug.h DMASoftware.h DMASPI.h DMATimerRead.h DMATimerWrite.h Dump.h EdgeCount.h EdgeInterruptPortF.h eDisk.h esp8266.h esp8266_base.h esp8266_blynk.h FIFO.h FIFOsimple.h FlashProgram.h FreqMeasure.h Fuzzy.h GPIO.h HD44780.h hw_adc.h hw_aes.h hw_can.h hw_ccm.h hw_comp.h hw_des.h hw_eeprom.h hw_emac.h hw_epi.h hw_ethernet.h hw_fan.h hw_flash.h hw_gpio.h hw_hibernate.h hw_i2c.h hw_i2s.h hw_ints.h hw_lcd.h hw_lpc.h hw_memmap.h hw_nvic.h hw_peci.h hw_pwm.h hw_qei.h hw_shamd5.h hw_ssi.h hw_sysctl.h hw_sysexc.h hw_timer.h hw_types.h hw_uart.h hw_udma.h hw_usb.h hw_watchdog.h I2C0.h I2C1.h I2C2.h I2C3.h I2CB1.h InputCapture.h interrupt.h IRDistance.h LaunchPad.h LED.h LLFifo.h lm4f120h5qr.h LPF.h Matrix.h MAX549.h MAX5353.h MQTT.h Nokia5110.h odometry.h opt3101.h PLL.h Profile.h PWM.h PWMDual.h PWMrobot.h random.h Sine.h SSD1306.h SSD2119.h ST7735.h ST7735_PortD.h Switch.h SwitchExternal.h SysTick.h SysTickInts.h Texas.h Timer.h Timer0A.h Timer0APWM.h Timer1A.h Timer2A.h Timer3A.h Timer4A.h Timer5A.h tm4c123gh6pm.h UART.h UART0int.h UART1.h UART1int.h UART2.h UART5.h Unified_Port_Init.h WifiSettings.h WTimer0A.h
