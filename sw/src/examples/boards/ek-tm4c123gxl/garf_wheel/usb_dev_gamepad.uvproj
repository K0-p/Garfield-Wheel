# Keil uVision project usb_dev_gamepad.uvproj, settings and files
target usb_dev_gamepad (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: usb_dev_gamepad
  AfterMake: fromelf --bin --output .\rvmdk\usb_dev_gamepad.bin .\rvmdk\usb_dev_gamepad.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_TM4C123GH6PM TARGET_IS_TM4C123_RA1 UART_BUFFERED
  c misc: --c99
  c include: ..;..\..\..\..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: usb_dev_gamepad.sct
  link misc: --entry Reset_Handler
  group Source
    ../drivers/: buttons.c
    ./: startup_rvmdk.S usb_gamepad_structs.c
    ../../../../utils/: uartstdio.c
    ../../../../: garf_wheel.c
  group Libraries
    ../../../../driverlib/rvmdk/: driverlib.lib
    ../../../../usblib/rvmdk/: usblib.lib
  group Documentation
    ./: readme.txt
